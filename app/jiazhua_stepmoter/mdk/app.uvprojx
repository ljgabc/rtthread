# Keil uVision project app.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: N32G003F5 Nationstech
  pack: Nationstech.N32G003_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0C00) IROM(0x08000000,0x7600) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: __SOFTFP__
  c include: ..\..\..\..\rt-thread;..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0xc00
  group app
    ../: main.c
    ../../../startup/: startup_n32g003.s
    ../../../libcpu/arm/cortex-m0/: context_gcc.S
    ../../../bsp/: bsp.c
    ../../../components/: modules.c
    ../../../libcpu/: libcpu.c
    ../../../os/: os.c
